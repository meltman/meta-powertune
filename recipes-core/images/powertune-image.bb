require recipes-fsl/images/imx-image-core.bb

SUMMARY = "PowerTune image for CompuLab IOT-GATE-iMX8Plus"

IMAGE_BASENAME = "powertune-image"
