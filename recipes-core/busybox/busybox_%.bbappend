SYSTEMD_AUTO_ENABLE:${PN}-syslog:iot-gate-imx8plus = "disable"
INITSCRIPT_PARAMS:${PN}-syslog:iot-gate-imx8plus = "disable"
