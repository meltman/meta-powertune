SYSTEMD_AUTO_ENABLE:${PN}-daemon:iot-gate-imx8plus = "disable"
SYSTEMD_AUTO_ENABLE:${PN}-dnsconfd:iot-gate-imx8plus = "disable"
INITSCRIPT_PARAMS:avahi-daemon:iot-gate-imx8plus = "disable"
INITSCRIPT_PARAMS:avahi-dnsconfd:iot-gate-imx8plus = "disable"
