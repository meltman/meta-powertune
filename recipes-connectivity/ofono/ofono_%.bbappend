SYSTEMD_AUTO_ENABLE:${PN}:iot-gate-imx8plus = "disable"
INITSCRIPT_PARAMS:iot-gate-imx8plus = "disable"
