SYSTEMD_AUTO_ENABLE:${PN}-client:iot-gate-imx8plus = "disable"
INITSCRIPT_PARAMS:${PN}-client:iot-gate-imx8plus = "disable"
