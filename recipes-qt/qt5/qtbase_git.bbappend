PACKAGECONFIG_FONTS:append = " fontconfig"
PACKAGECONFIG:append = " gif"
